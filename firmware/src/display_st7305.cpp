#include "display_st7305.h"
#include <esp_heap_caps.h>
#include <string.h>

// ── SPI ───────────────────────────────────────────────────────────────────────
static SPIClass _spi(FSPI);
static const SPISettings _spiCfg(10000000, MSBFIRST, SPI_MODE0);

// ── 5×8 ASCII font, chars 0x20–0x7E, column-major, bit0 = topmost row ────────
// Source: classic Arduino/Adafruit GFX 5×7 glyph table (public domain)
static const uint8_t FONT5X8[][5] PROGMEM = {
  {0x00,0x00,0x00,0x00,0x00}, // 0x20  ' '
  {0x00,0x00,0x5F,0x00,0x00}, // 0x21  '!'
  {0x00,0x07,0x00,0x07,0x00}, // 0x22  '"'
  {0x14,0x7F,0x14,0x7F,0x14}, // 0x23  '#'
  {0x24,0x2A,0x7F,0x2A,0x12}, // 0x24  '$'
  {0x23,0x13,0x08,0x64,0x62}, // 0x25  '%'
  {0x36,0x49,0x55,0x22,0x50}, // 0x26  '&'
  {0x00,0x05,0x03,0x00,0x00}, // 0x27  '''
  {0x00,0x1C,0x22,0x41,0x00}, // 0x28  '('
  {0x00,0x41,0x22,0x1C,0x00}, // 0x29  ')'
  {0x14,0x08,0x3E,0x08,0x14}, // 0x2A  '*'
  {0x08,0x08,0x3E,0x08,0x08}, // 0x2B  '+'
  {0x00,0x50,0x30,0x00,0x00}, // 0x2C  ','
  {0x08,0x08,0x08,0x08,0x08}, // 0x2D  '-'
  {0x00,0x60,0x60,0x00,0x00}, // 0x2E  '.'
  {0x20,0x10,0x08,0x04,0x02}, // 0x2F  '/'
  {0x3E,0x51,0x49,0x45,0x3E}, // 0x30  '0'
  {0x00,0x42,0x7F,0x40,0x00}, // 0x31  '1'
  {0x42,0x61,0x51,0x49,0x46}, // 0x32  '2'
  {0x21,0x41,0x45,0x4B,0x31}, // 0x33  '3'
  {0x18,0x14,0x12,0x7F,0x10}, // 0x34  '4'
  {0x27,0x45,0x45,0x45,0x39}, // 0x35  '5'
  {0x3C,0x4A,0x49,0x49,0x30}, // 0x36  '6'
  {0x01,0x71,0x09,0x05,0x03}, // 0x37  '7'
  {0x36,0x49,0x49,0x49,0x36}, // 0x38  '8'
  {0x06,0x49,0x49,0x29,0x1E}, // 0x39  '9'
  {0x00,0x36,0x36,0x00,0x00}, // 0x3A  ':'
  {0x00,0x56,0x36,0x00,0x00}, // 0x3B  ';'
  {0x08,0x14,0x22,0x41,0x00}, // 0x3C  '<'
  {0x14,0x14,0x14,0x14,0x14}, // 0x3D  '='
  {0x00,0x41,0x22,0x14,0x08}, // 0x3E  '>'
  {0x02,0x01,0x51,0x09,0x06}, // 0x3F  '?'
  {0x32,0x49,0x79,0x41,0x3E}, // 0x40  '@'
  {0x7E,0x11,0x11,0x11,0x7E}, // 0x41  'A'
  {0x7F,0x49,0x49,0x49,0x36}, // 0x42  'B'
  {0x3E,0x41,0x41,0x41,0x22}, // 0x43  'C'
  {0x7F,0x41,0x41,0x22,0x1C}, // 0x44  'D'
  {0x7F,0x49,0x49,0x49,0x41}, // 0x45  'E'
  {0x7F,0x09,0x09,0x09,0x01}, // 0x46  'F'
  {0x3E,0x41,0x49,0x49,0x7A}, // 0x47  'G'
  {0x7F,0x08,0x08,0x08,0x7F}, // 0x48  'H'
  {0x00,0x41,0x7F,0x41,0x00}, // 0x49  'I'
  {0x20,0x40,0x41,0x3F,0x01}, // 0x4A  'J'
  {0x7F,0x08,0x14,0x22,0x41}, // 0x4B  'K'
  {0x7F,0x40,0x40,0x40,0x40}, // 0x4C  'L'
  {0x7F,0x02,0x04,0x02,0x7F}, // 0x4D  'M'
  {0x7F,0x04,0x08,0x10,0x7F}, // 0x4E  'N'
  {0x3E,0x41,0x41,0x41,0x3E}, // 0x4F  'O'
  {0x7F,0x09,0x09,0x09,0x06}, // 0x50  'P'
  {0x3E,0x41,0x51,0x21,0x5E}, // 0x51  'Q'
  {0x7F,0x09,0x19,0x29,0x46}, // 0x52  'R'
  {0x46,0x49,0x49,0x49,0x31}, // 0x53  'S'
  {0x01,0x01,0x7F,0x01,0x01}, // 0x54  'T'
  {0x3F,0x40,0x40,0x40,0x3F}, // 0x55  'U'
  {0x1F,0x20,0x40,0x20,0x1F}, // 0x56  'V'
  {0x3F,0x40,0x38,0x40,0x3F}, // 0x57  'W'
  {0x63,0x14,0x08,0x14,0x63}, // 0x58  'X'
  {0x07,0x08,0x70,0x08,0x07}, // 0x59  'Y'
  {0x61,0x51,0x49,0x45,0x43}, // 0x5A  'Z'
  {0x00,0x7F,0x41,0x41,0x00}, // 0x5B  '['
  {0x02,0x04,0x08,0x10,0x20}, // 0x5C  '\'
  {0x00,0x41,0x41,0x7F,0x00}, // 0x5D  ']'
  {0x04,0x02,0x01,0x02,0x04}, // 0x5E  '^'
  {0x40,0x40,0x40,0x40,0x40}, // 0x5F  '_'
  {0x00,0x01,0x02,0x04,0x00}, // 0x60  '`'
  {0x20,0x54,0x54,0x54,0x78}, // 0x61  'a'
  {0x7F,0x48,0x44,0x44,0x38}, // 0x62  'b'
  {0x38,0x44,0x44,0x44,0x20}, // 0x63  'c'
  {0x38,0x44,0x44,0x48,0x7F}, // 0x64  'd'
  {0x38,0x54,0x54,0x54,0x18}, // 0x65  'e'
  {0x08,0x7E,0x09,0x01,0x02}, // 0x66  'f'
  {0x0C,0x52,0x52,0x52,0x3E}, // 0x67  'g'
  {0x7F,0x08,0x04,0x04,0x78}, // 0x68  'h'
  {0x00,0x44,0x7D,0x40,0x00}, // 0x69  'i'
  {0x20,0x40,0x44,0x3D,0x00}, // 0x6A  'j'
  {0x7F,0x10,0x28,0x44,0x00}, // 0x6B  'k'
  {0x00,0x41,0x7F,0x40,0x00}, // 0x6C  'l'
  {0x7C,0x04,0x18,0x04,0x78}, // 0x6D  'm'
  {0x7C,0x08,0x04,0x04,0x78}, // 0x6E  'n'
  {0x38,0x44,0x44,0x44,0x38}, // 0x6F  'o'
  {0x7C,0x14,0x14,0x14,0x08}, // 0x70  'p'
  {0x08,0x14,0x14,0x18,0x7C}, // 0x71  'q'
  {0x7C,0x08,0x04,0x04,0x08}, // 0x72  'r'
  {0x48,0x54,0x54,0x54,0x20}, // 0x73  's'
  {0x04,0x3F,0x44,0x40,0x20}, // 0x74  't'
  {0x3C,0x40,0x40,0x40,0x7C}, // 0x75  'u'
  {0x1C,0x20,0x40,0x20,0x1C}, // 0x76  'v'
  {0x3C,0x40,0x30,0x40,0x3C}, // 0x77  'w'
  {0x44,0x28,0x10,0x28,0x44}, // 0x78  'x'
  {0x0C,0x50,0x50,0x50,0x3C}, // 0x79  'y'
  {0x44,0x64,0x54,0x4C,0x44}, // 0x7A  'z'
  {0x00,0x08,0x36,0x41,0x00}, // 0x7B  '{'
  {0x00,0x00,0x7F,0x00,0x00}, // 0x7C  '|'
  {0x00,0x41,0x36,0x08,0x00}, // 0x7D  '}'
  {0x08,0x08,0x2A,0x1C,0x08}, // 0x7E  '~'
};

// ── SPI helpers ───────────────────────────────────────────────────────────────

void DisplayST7305::writeCmd(uint8_t cmd) {
  digitalWrite(LCD_DC, LOW);
  digitalWrite(LCD_CS, LOW);
  _spi.beginTransaction(_spiCfg);
  _spi.transfer(cmd);
  _spi.endTransaction();
  digitalWrite(LCD_CS, HIGH);
}

void DisplayST7305::writeData(uint8_t data) {
  digitalWrite(LCD_DC, HIGH);
  digitalWrite(LCD_CS, LOW);
  _spi.beginTransaction(_spiCfg);
  _spi.transfer(data);
  _spi.endTransaction();
  digitalWrite(LCD_CS, HIGH);
}

// ── Init sequence ─────────────────────────────────────────────────────────────
// Ported from kylehase/ESPHome-ST7305-RLCD which itself is ported from the
// Waveshare reference driver for the ESP32-S3-RLCD-4.2 board.

void DisplayST7305::initSequence() {
  writeCmd(0xD6); writeData(0x17); writeData(0x02);   // NVM load
  writeCmd(0xD1); writeData(0x01);                    // booster on
  writeCmd(0xC0); writeData(0x11); writeData(0x04);   // gate voltage
  writeCmd(0xC1);
    writeData(0x69); writeData(0x69); writeData(0x69); writeData(0x69);
  writeCmd(0xC2);
    writeData(0x19); writeData(0x19); writeData(0x19); writeData(0x19);
  writeCmd(0xC4);
    writeData(0x4B); writeData(0x4B); writeData(0x4B); writeData(0x4B);
  writeCmd(0xC5);
    writeData(0x19); writeData(0x19); writeData(0x19); writeData(0x19);
  writeCmd(0xD8); writeData(0x80); writeData(0xE9);   // oscillator
  writeCmd(0xB2); writeData(0x02);                    // frame rate
  writeCmd(0xB3);                                     // gate EQ HP
    writeData(0xE5); writeData(0xF6); writeData(0x05); writeData(0x46);
    writeData(0x77); writeData(0x77); writeData(0x77); writeData(0x77);
    writeData(0x76); writeData(0x45);
  writeCmd(0xB4);                                     // gate EQ LP
    writeData(0x05); writeData(0x46);
    writeData(0x77); writeData(0x77); writeData(0x77); writeData(0x77);
    writeData(0x76); writeData(0x45);
  writeCmd(0x62); writeData(0x32); writeData(0x03); writeData(0x1F);
  writeCmd(0xB7); writeData(0x13);
  writeCmd(0xB0); writeData(0x64);  // row count = LCD_H/3 = 100 = 0x64
  writeCmd(0x11);                   // sleep out
  delay(200);
  writeCmd(0xC9); writeData(0x00);
  writeCmd(0x36); writeData(0x48);  // MADCTL: MX+BGR
  writeCmd(0x3A); writeData(0x11);  // pixel format: 1-bit
  writeCmd(0xB9); writeData(0x20);  // gamma
  writeCmd(0xB8); writeData(0x29);  // panel mode
  writeCmd(0x21);                   // display inversion on (white=1, black=0)
  writeCmd(0x2A); writeData(0x12); writeData(0x2A);  // col window
  writeCmd(0x2B); writeData(0x00); writeData(0xC7);  // row window
  writeCmd(0x35); writeData(0x00);  // tearing effect line on
  writeCmd(0xD0); writeData(0xFF);
  writeCmd(0x38);                   // high power mode (faster refresh)
  writeCmd(0x29);                   // display on
}

// ── Public API ────────────────────────────────────────────────────────────────

void DisplayST7305::begin() {
  _spi.begin(LCD_CLK, /*MISO=*/-1, LCD_MOSI, /*SS=*/-1);

  pinMode(LCD_CS,  OUTPUT); digitalWrite(LCD_CS,  HIGH);
  pinMode(LCD_DC,  OUTPUT); digitalWrite(LCD_DC,  HIGH);
  pinMode(LCD_RST, OUTPUT);

  digitalWrite(LCD_RST, LOW);  delay(10);
  digitalWrite(LCD_RST, HIGH); delay(120);

  initSequence();

  const size_t fbSize = (size_t)LCD_W * LCD_H / 8;  // 15 000 bytes
  fb = (uint8_t*)heap_caps_malloc(fbSize, MALLOC_CAP_SPIRAM);
  if (!fb) fb = (uint8_t*)malloc(fbSize);
  if (fb) memset(fb, 0xFF, fbSize);  // start white (0x21 inversion active)
}

void DisplayST7305::clear() {
  if (fb) memset(fb, 0xFF, (size_t)LCD_W * LCD_H / 8);
}

// Pixel address formula derived from ESPHome landscape LUT:
//   buffer index = (x/2) * (H/4) + (H-1-y)/4
//   bit mask     = 1 << (7 - (((H-1-y)%4 << 1) | (x%2)))
// Because 0x21 inversion is on: on=true → black → clear bit; on=false → white → set bit
void DisplayST7305::setPixel(int x, int y, bool on) {
  if ((unsigned)x >= LCD_W || (unsigned)y >= LCD_H || !fb) return;
  const int H4    = LCD_H >> 2;          // 75
  const int iy    = (LCD_H - 1) - y;
  const uint32_t idx  = (uint32_t)(x >> 1) * H4 + (iy >> 2);
  const uint8_t  mask = 1u << (7 - (((iy & 3) << 1) | (x & 1)));
  if (on) fb[idx] &= ~mask;
  else    fb[idx] |=  mask;
}

void DisplayST7305::drawHLine(int x, int y, int w, bool on) {
  for (int i = x; i < x + w; i++) setPixel(i, y, on);
}

void DisplayST7305::drawRect(int x, int y, int w, int h, bool on) {
  drawHLine(x, y,         w, on);
  drawHLine(x, y + h - 1, w, on);
  for (int i = y + 1; i < y + h - 1; i++) {
    setPixel(x,         i, on);
    setPixel(x + w - 1, i, on);
  }
}

void DisplayST7305::fillRect(int x, int y, int w, int h, bool on) {
  for (int row = y; row < y + h; row++) drawHLine(x, row, w, on);
}

// drawText: renders ASCII 0x20–0x7E using the 5×8 bitmap font.
// Each character cell is 6×8 logical pixels (5 + 1 spacing) scaled by `size`.
void DisplayST7305::drawText(int x, int y, const char* txt, int size, bool on) {
  int cx = x;
  for (; *txt; ++txt) {
    uint8_t c = (uint8_t)*txt;
    if (c < 0x20 || c > 0x7E) { cx += 6 * size; continue; }
    const uint8_t* g = FONT5X8[c - 0x20];
    for (int col = 0; col < 5; col++) {
      uint8_t colData = pgm_read_byte(&g[col]);
      for (int row = 0; row < 8; row++) {
        if ((colData >> row) & 1) {
          for (int sy = 0; sy < size; sy++)
            for (int sx = 0; sx < size; sx++)
              setPixel(cx + col * size + sx, y + row * size + sy, on);
        }
      }
    }
    cx += 6 * size;
  }
}

// refresh: push framebuffer to display via SPI.
// Keeps CS asserted across the 0x2C command byte + all 15 000 data bytes,
// matching the pattern required by the ST7305 (same as ESPHome write_display_).
void DisplayST7305::refresh() {
  if (!fb) return;

  writeCmd(0x2A); writeData(0x12); writeData(0x2A);  // col window
  writeCmd(0x2B); writeData(0x00); writeData(0xC7);  // row window

  _spi.beginTransaction(_spiCfg);
  digitalWrite(LCD_DC, LOW);
  digitalWrite(LCD_CS, LOW);
  _spi.transfer(0x2C);           // memory write command
  digitalWrite(LCD_DC, HIGH);   // switch to data
  _spi.transferBytes(fb, nullptr, (size_t)LCD_W * LCD_H / 8);
  digitalWrite(LCD_CS, HIGH);
  _spi.endTransaction();
}

// refreshColumns: same as refresh(), but the row window (0x2B, one row per x
// pair — see setPixel's idx formula) is narrowed to the requested x range.
void DisplayST7305::refreshColumns(int x0, int x1) {
  if (!fb) return;
  if (x0 < 0) x0 = 0;
  if (x1 > LCD_W - 1) x1 = LCD_W - 1;
  if (x0 > x1) return;
  const int p0 = x0 >> 1, p1 = x1 >> 1;      // 0..199
  const int rowBytes = LCD_H >> 2;           // 75

  writeCmd(0x2A); writeData(0x12); writeData(0x2A);          // all columns
  writeCmd(0x2B); writeData((uint8_t)p0); writeData((uint8_t)p1);

  _spi.beginTransaction(_spiCfg);
  digitalWrite(LCD_DC, LOW);
  digitalWrite(LCD_CS, LOW);
  _spi.transfer(0x2C);
  digitalWrite(LCD_DC, HIGH);
  _spi.transferBytes(fb + (size_t)p0 * rowBytes, nullptr, (size_t)(p1 - p0 + 1) * rowBytes);
  digitalWrite(LCD_CS, HIGH);
  _spi.endTransaction();
}
